<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mutlirtl_3chanRX_to_cfile</value></param>
<param><key>author</key><value>Carl Kylin</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>3 chanels saved to 3 separate cfiles</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>mutlirtl_3chanRX_to_cfile</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>ch0_fname</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>ch1_fname</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_2</value></param>
<param><key>file</key><value>ch2_fname</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>nsamples</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_1</value></param>
<param><key>num_items</key><value>nsamples</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_2</value></param>
<param><key>num_items</key><value>nsamples</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ch0_fname</value></param>
<param><key>label</key><value>ch0-fname</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"ch0.cfile"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ch0_id_string</value></param>
<param><key>label</key><value>ch0-id-string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ch1_fname</value></param>
<param><key>label</key><value>ch1-fname</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"ch1.cfile"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ch1_id_string</value></param>
<param><key>label</key><value>ch1-id-string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"1"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ch2_fname</value></param>
<param><key>label</key><value>ch2-fname</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"ch2.cfile"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ch2_id_string</value></param>
<param><key>label</key><value>ch2-id-string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"2"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_rec</value></param>
<param><key>label</key><value>f-rec</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>600e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>f_sync</value></param>
<param><key>label</key><value>f-sync</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>600e6</value></param>
</block>
<block>
<key>multi_rtl_source</key>
<param><key>id</key><value>multi_rtl_source_1</value></param>
<param><key>freq0</key><value>f_rec</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>id_string0</key><value>ch0_id_string</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>sync_gain0</key><value>10</value></param>
<param><key>freq1</key><value>f_rec</value></param>
<param><key>gain_mode1</key><value>False</value></param>
<param><key>id_string1</key><value>ch1_id_string</value></param>
<param><key>gain1</key><value>10</value></param>
<param><key>sync_gain1</key><value>10</value></param>
<param><key>freq2</key><value>f_rec</value></param>
<param><key>gain_mode2</key><value>False</value></param>
<param><key>id_string2</key><value>ch2_id_string</value></param>
<param><key>gain2</key><value>10</value></param>
<param><key>sync_gain2</key><value>10</value></param>
<param><key>corr</key><value>0</value></param>
<param><key>nchan</key><value>3</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync_freq</key><value>f_sync</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nsamples</value></param>
<param><key>label</key><value>nsamples</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp-rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_1</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_2</source_block_id><sink_block_id>blocks_file_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multi_rtl_source_1</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multi_rtl_source_1</source_block_id><sink_block_id>blocks_head_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multi_rtl_source_1</source_block_id><sink_block_id>blocks_head_2</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
</flow_graph>
